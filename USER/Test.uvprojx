# Keil uVision project Test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CSTX +hex
  c flags: uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE\LED;..\HARDWARE\WDG;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\TIMER;..\HARDWARE\BC26;..\HARDWARE\ADC;..\HARDWARE\DHT11;..\HARDWARE\RELAY;..\HARDWARE\KEY;..\HARDWARE\adc;..\HARDWARE\LDR;..\HARDWARE\TS;..\HARDWARE\OLED;..\freeRTOS\include;..\freeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\systick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/BC26/: BC26.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/adc/: adcx.c
    ../HARDWARE/LDR/: LDR.c
    ../HARDWARE/TS/: TS.c
    ../HARDWARE/OLED/: oled.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/systick/: SysTick.c
  group LIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group START_UP
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group freeRTOS_core
    ../freeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freeRTOS_port
    ../freeRTOS/portable/MemMang/: heap_4.c
    ../freeRTOS/portable/RVDS/ARM_CM3/: port.c
